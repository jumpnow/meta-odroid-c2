FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

require secure-odroid.inc

COMPATIBLE_MACHINE  = "odroid-c2"
