PACKAGECONFIG_append = " accessibility linuxfb no-opengl"
PACKAGECONFIG_remove = "examples tests"
